# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\Drivers\SYS\Inc;..\Drivers\BSP\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Start
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group README
    ../: README.TXT
  group Drivers/BSP
    ../Drivers/BSP/Src/: Tracking.c Control.c
  group Drivers/SYS
    ../Drivers/SYS/Src/: sys.c delay.c
